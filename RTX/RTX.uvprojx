# Keil uVision project RTX.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RTX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:STM32Cube HAL:COMMON 1.7.0, Device:STM32Cube HAL:CORTEX 1.7.0, Device:STM32Cube HAL:FLASH 1.7.0, Device:STM32Cube HAL:GPIO 1.7.0, Device:STM32Cube HAL:RCC 1.7.0, Device:Startup 1.0.0
